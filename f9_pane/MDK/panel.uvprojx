# Keil uVision project panel.uvprojx, settings and files
target panel (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: HC32L130F8UA HDSC
  pack: HDSC.HC32L130.1.0.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: multi_switch_control +hex
  AfterMake: fromelf  --bin  -o ./output/release/multi_switch_control.bin ./output/multi_switch_control.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 wLevel=2
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc;..\source\driver\inc;..\source\common;..\source;..\source\common;..\source\button;..\source\public_ interruption;..\source\indicator;..\source\control;..\source\communication;..\source\communication\agreement;..\source\business_scheduler;..\source\dial_switch;..\source\pwm;..\source\thyristor;..\source\rgb;..\source\system_clock;..\source\data
  library: MicroLIB
  memory RVCT4: ROM 0x1200 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group user
    ../source/: main.c
  group user_agreement
    ../source/communication/agreement/: user_agreement_receive.c user_agreement_send.c
  group logic_control
    ../source/logic_control/: logic_control_business.c
  group communication
    ../source/communication/: communication_business.c communication_driver.c communication_bsp_hc32l130.c
  group gpio_manage
    ../source/gpio_manage/: gpio_manage_business.c gpio_manage_driver.c gpio_manage_bsp_hc32l130.c
  group rgb
    ../source/rgb/: rgb_business.c rgb_driver.c rgb_bsp_hc32l130.c
  group data
    ../source/data/: data_business.c
  group infrared_induction
    ../source/infrared_induction/: induction_business.c inductionbsp_hc32l130.c
  group business_scheduler
    ../source/business_scheduler/: business_scheduler.c
  group system_clock
    ../source/system_clock/: system_clock.c
  group hc32l13_bsp
    ../source/driver/src/: ddl.c sysctrl.c gpio.c flash.c uart.c adt.c timer3.c bt.c spi.c wdt.c
  group hc32l13_common
    ./: startup_hc32l13x.s
    ../source/common/: system_hc32l13x.c interrupts_hc32l13x.c
  group readme
    ../: readme.txt
software components: CMSIS:CORE 5.4.0
